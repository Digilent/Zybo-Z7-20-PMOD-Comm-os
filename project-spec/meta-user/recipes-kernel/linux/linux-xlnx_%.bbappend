SRC_URI += "file://user_2019-11-18-14-38-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

